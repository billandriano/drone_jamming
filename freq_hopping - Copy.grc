options:
  parameters:
    generate_options: qt_gui
    id: freq_hopping
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    label: BB gain
    start: '10'
    step: '10'
    stop: '60'
    value: var_bb_gain
    widget: slider
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: IF gain
    start: '10'
    step: '10'
    stop: '60'
    value: var_if_gain
    widget: slider
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF gain
    start: '10'
    step: '10'
    stop: '60'
    value: var_rf_gain
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: var_bb_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: var_if_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: var_rf_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: analog_noise_source_x_1
  id: analog_noise_source_x
  parameters:
    amp: '100'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import time
      import pmt
      from gnuradio import gr
      import threading

      class blk(gr.basic_block):
          def __init__(self, hop_freqs=[100e6, 120e6, 150e6], hop_rate=2):
              gr.basic_block.__init__(self,
                  name='RF Freq Hopper Controller',
                  in_sig=None,
                  out_sig=None)
              
              self.hop_freqs = hop_freqs
              self.hop_rate = hop_rate
              self.current_index = 0

              self.message_port_register_out(pmt.intern('cmd'))
              self.thread = threading.Thread(target=self.hop_loop)
              self.thread.daemon = True
              self.thread.start()

          def hop_loop(self):
              while True:
                  freq = self.hop_freqs[self.current_index]
                  msg = pmt.cons(pmt.intern("freq"), pmt.from_double(freq))
                  self.message_port_pub(pmt.intern('cmd'), msg)
                  self.current_index = (self.current_index + 1) % len(self.hop_freqs)
                  time.sleep(self.hop_rate)
    hop_freqs: '[100e6, 120e6, 150e6]'
    hop_rate: '0.5'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: 20e6
    fc: '0'
    fftsize: '1024'
    plotconst: 'False'
    plottime: 'False'
    plotwaterfall: 'False'
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}

connections:
- [analog_noise_source_x_1, '0', qtgui_sink_x_0, '0']
- [epy_block_0_0, cmd, qtgui_sink_x_0, freq]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
